## Config.in
```kconfig
menu "rearmit.linux"
    source "$BR2_EXTERNAL_REARMIT_PATH/package/rearmit/alllinuxfirmwares/Config.in"
endmenu
```
